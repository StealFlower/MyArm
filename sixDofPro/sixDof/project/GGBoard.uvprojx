# Keil uVision project GGBoard.uvprojx, settings and files
target Engineer (6140000::V6.14::ARMCLANG)
  device: STM32G473CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GGBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: STM32G473xx,USE_HAL_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_FULL_LL_DRIVER,CCMRAM
  c misc: -Wno-pragma-pack
  c include: ..\bspLib;..\devLib;..\halLib;..\user;..\halLib\Inc;..\taskLib;..\dspLib;..\motLib;..\module;..\algLib\eigen-3.4.0;..\algLib\eigen-3.4.0\Eigen;..\algLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.cpp board.cpp schedule.cpp stm32g4xx_it.cpp
  group taskLib
    ../taskLib/: devList.cpp ledTask.cpp stateTask.cpp chassisTask.cpp gimbalTask.cpp judgeTask.cpp
  group motLib
    ../motLib/: SMUniversal.cpp offsetStateMachine.cpp oreMotionStateMachine.cpp takeGoldState.cpp takeSilveryState.cpp pickOreState.cpp exchangeOreState.cpp handModeState.cpp hidArmorState.cpp checkOreState.cpp
  group module
    ../module/: chassis.cpp gimbal.cpp judge.cpp imageTran.cpp air.cpp oreBin.cpp
  group devLib
    ../devLib/: led.cpp motor.cpp dbus.cpp dmMotor.cpp judgement.cpp vision.cpp gugu.cpp wrist.cpp doubleMotor.cpp arm.cpp
  group algLib
    ../algLib/: virtualtask.cpp stateMachine.cpp pid.cpp online.cpp cycle.cpp pathPlan.cpp filter.cpp varCalt.cpp crc.cpp asr.cpp kinematics.cpp dynamics.cpp
  group bspLib
    ../bspLib/: iwdg.cpp fdcan.cpp flash.cpp
  group halLib
    ../halLib/: startup_stm32g473xx.s
    ../user/: system_stm32g4xx.c
    ../halLib/Src/: stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_exti.c stm32g4xx_ll_usart.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_tim.c stm32g4xx_ll_dma.c stm32g4xx_ll_spi.c stm32g4xx_ll_adc.c stm32g4xx_ll_cordic.c stm32g4xx_ll_fmac.c stm32g4xx_ll_utils.c stm32g4xx_ll_opamp.c stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_gpio.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_uart.c
  group dspLib
    ../dspLib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
